## firmware/boards/ht/ht_main/board.yml
```yaml
board:
  name: ht_main
  full_name: HT MAIN-01
  vendor: ht
  socs:
    - name: stm32g474xx
```
